XSECTION
PROPOSED XS

Tolerance = 0.10


PATTERN DGN = r:\Roadway\proj\17bp.6.r.20_rdy_pat.dgn
   PATTERN SET
      JOB NUMBER = rdy
      BASELINE = L
      HORIZ SCALE = 10
      VERT SCALE = 10
      type = line
      lvname = Pattern 1


Define "slope text height" 1.25
Define "slope text width" 1.25
Define "elev text height" 1.25
Define "elev text width" 1.25
Define "slope text height" 1.25
Define "slope text width" 1.25


define "tm01 config" 0
define "tm02 config" 3

define "sh01 width cut" 4	               
define "sh01 width fill" 4	               
define "sh01 slope" 0.08              
define "sh01 paved" 0                  

define "ld01 ditch width" 8
define "ld01 ditch slope" 4

DEFINE "BD01 RAIL OFFSET" 4 



define "pavement depth" 12
define "bituminous depth" 12
define "resurfacing depth" 2

DEFINE "draw guardrail" 0

define "eop in xsc" 0

include F:\USTN\Roadway\NCDOT\Criteria Files\V8 criteria files\standard.eng
include F:\USTN\Roadway\NCDOT\Criteria Files\V8 criteria files\cc_defs.eng 


DEFINE_DGN "EXIST DGN EOP"\
   DGN = R:\FinalSurvey\230075_ncdot_fs.dgn\
   type = line, line_string, arc\
   lvname = exist road eop\
   

  
   
CRITERIA FOR SHAPE CLUSTER
   SHAPE CLUSTER BASELINE = L
   SHAPE CLUSTER PROFILE = proL
   SHAPE CLUSTER TIE = 0

   SIDE SLOPE LT where (station >= 15+00 and station <= 15+50)
	include F:\USTN\Roadway\NCDOT\Criteria Files\V8 criteria files\tmplt02.cri
 	include F:\USTN\Roadway\NCDOT\Criteria Files\V8 criteria files\shld01.cri
      include F:\USTN\Roadway\NCDOT\Criteria Files\V8 criteria files\ldss01.cri     

   SIDE SLOPE RT where (station >= 15+00 and station <= 15+50)	       
	include F:\USTN\Roadway\NCDOT\Criteria Files\V8 criteria files\tmplt02.cri
 	include F:\USTN\Roadway\NCDOT\Criteria Files\V8 criteria files\shld01.cri
      include F:\USTN\Roadway\NCDOT\Criteria Files\V8 criteria files\ldss01.cri 

 
SHAPE DGN = R:\Roadway\shp\230075_rdy_shp.dgn
   SHAPE SET
   TYPE = CMP_SHAPE
   lvname = Prop Geopak Pavement Shape Dependent

XS DGN = R:\Roadway\xsc\17bp.6.r.20_rdy_xsc_L.dgn
   EXISTING GROUND LINE
   lvname=Exist XS Ground Line
   TYPE=LINE


PLOT PARAMETERS
   LINE
    LVname=Prop XS Dump Level
     

pavement thickness = 0.0
do not fill gaps between clusters
WRITE XS INTO DGN= R:\Roadway\xsc\17bp.6.r.20_rdy_xsc_L.dgn


