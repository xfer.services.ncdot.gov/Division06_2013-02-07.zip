HEC-RAS study BigBranch.prj: Big Branch into Monie Swamp

--- BigBranch.g01 (geometry) --- (continued)

Type RM Length L Ch R = 1 ,1463    ,489.6,488,431.31
XS GIS Cut Line= 4
     2089352.337      131451.748     2089401.465      129838.712
     2088312.461      128831.588     2085725.053      127816.276
#Sta/Elev= 30
       0   35.33  597.17   34.48  673.29   36.52  718.78   34.56   874.2   34.06
  901.03    35.7 1119.97   34.75 1157.52    36.6 1223.97   34.52  1483.4   35.73
 1730.14   33.64 2133.95   34.52 2638.59   33.11 2644.01   31.13 2655.25    33.1
  2940.5   34.73 2949.19   33.12 3091.49   34.46  3276.4   33.26 3302.67   34.59
 3465.47   33.18 3891.77    37.4 4301.88   36.76 4342.08   38.84 5260.89   36.29
 5505.63   39.53 5610.96   38.68 5730.82   41.23 5761.88    43.5 5876.59   42.38
#Mann= 3 , 0 , 0
       0     .12       0 2638.59     .06       0 2655.25     .12       0
#XS Ineff= 2 , 0
       0    1640      49    3110       0      49
Bank Sta=2638.59,2655.25
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,975     ,481.59,499.64,473.2
XS GIS Cut Line= 4
     2089794.489      131558.192     2089892.745      129503.004
     2088402.529      128422.188     2085725.053      127693.456
#Sta/Elev= 30
       0   37.27   28.68   38.33   56.41   35.41  183.53   34.14 1225.05   35.34
 1241.97   33.85 1777.99   33.82 1861.15   35.31 2344.05   32.97  2477.1   33.33
 2508.06   35.12 2573.14   33.37 3216.53   32.89  3229.9   30.97 3236.55   33.19
 3728.61   33.88 3758.25   35.54 3846.23   33.39 4029.19   33.19 4302.45   33.46
 4373.63   35.44 4591.15    33.5  4652.5   35.07 5249.07   33.99 5476.51   37.87
  5727.1   38.48 5910.96    35.6 6357.37   37.97 6473.36   41.26 6673.31   42.76
#Mann= 3 , 0 , 0
       0     .12       0 3216.53     .06       0 3236.55     .12       0
#XS Ineff= 2 , 0
       0    2070      49    3980       0      49
Bank Sta=3216.53,3236.55
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,475     ,381.2,435.06,451.38
XS GIS Cut Line= 4
     2090023.753       131566.38     2090293.957       129191.86
     2088508.973       127922.72     2085667.737      127447.816
#Sta/Elev= 30
       0   34.91   395.5   35.77  671.94   33.76  823.39   35.78  976.91   33.66
 1689.98   35.25  1844.2   33.55 1927.29   35.12 2095.05   33.22 2909.19   33.02
 3685.57   34.28 3695.53   31.87 3707.95   33.84 4534.85   35.54 4595.97   33.77
  4908.6   33.96 5172.96   35.87 5208.54   33.49 5813.56   35.19 5861.87   33.45
 5918.38    35.1 6295.98   33.97 6355.09   34.75 6367.06   36.98 6550.24   34.43
 6701.39   37.78 6771.73   36.65 7021.84   38.51 7058.43   40.62 7460.67   42.51
#Mann= 3 , 0 , 0
       0     .12       0 3685.57     .06       0 3707.95     .12       0
#XS Ineff= 2 , 0
       0    2620      49    4730       0      49
Bank Sta=3685.57,3707.95
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,40      ,40.35,40.35,40.35
XS GIS Cut Line= 4
     2090253.017      131550.004     2090465.905      129159.108
     2088721.861      127316.808     2085602.233      127161.236
#Sta/Elev= 30
       0   34.51   497.6   33.94  542.48    36.4  682.16   33.66 1029.94   36.22
 1076.82   33.75 1093.95   35.23  1504.7   33.63    1673   35.25 1764.71   33.29
 2035.69   35.14 2477.55    33.1  3901.4   34.53 3907.31   31.89 3925.58   33.74
 4262.81   33.46  4350.9   36.79 4404.91   34.06 4508.76   33.57 4606.49   35.48
 4936.53   33.51 5649.01   33.51 5663.69   35.21 5783.07   33.28 6885.62   33.43
 7181.04   38.73 7374.07   37.46 7450.48   40.18 7711.51   39.25 8060.74   41.79
#Mann= 3 , 0 , 0
       0     .12       0  3901.4     .06       0 3925.58     .12       0
#XS Ineff= 2 , 0
       0    2800      49    4950       0      49
Bank Sta=3901.4,3925.58
Exp/Cntr=.3,.1

Chan Stop Cuts=-1
