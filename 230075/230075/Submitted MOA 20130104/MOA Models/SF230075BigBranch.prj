HEC-RAS study SF230075BigBranch.prj: SF230075 Big Branch SR 1006

--- SF230075BigBranch.g05 (geometry) --- (continued)

Type RM Length L Ch R = 1 ,3766    ,342.57,348.16,351.15
XS GIS Cut Line= 2
     2088623.178      131570.575     2085041.582      129177.562
#Sta/Elev= 30
       0   40.04 1049.94   37.74 1078.86   38.55 1160.06   35.92  1242.5   36.82
 1357.58   35.63 1368.13   34.51 1533.46   34.28 1545.89   32.39 1553.79    34.4
 1731.06   34.34 1884.65   37.78 1917.32   36.69 2293.91   38.01 2303.29   36.26
 2308.09   37.96 2379.22   38.22 2394.34   37.13  2448.7   38.26  2740.5   35.74
 2982.88   36.92 3208.53   36.09 3565.44   38.88 3602.72   38.11 3613.26   39.91
 3655.97   42.01 3724.76   41.22 3732.78   42.09  3776.5   40.74 4307.48   45.06
#Mann= 3 , 0 , 0
       0     .12       0 1533.46     .06       0 1553.79     .12       0
#XS Ineff= 2 , 0
       0    1380      40    1950       0      40
Permanent Ineff=
       F       F
Bank Sta=1533.46,1553.79
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,3417    ,400.74,526.4,687.35
XS GIS Cut Line= 3
     2087973.419      131095.142     2087830.789      130635.557
     2085184.212      128797.216
#Sta/Elev= 30
       0   39.32  534.39   39.17     664   37.95  734.11   34.34  870.35   34.72
  877.29   32.77  888.87   34.67 1063.97   34.82 1149.31   37.56  1301.2   36.98
 1447.81   37.97  2039.9   36.03 2852.46   36.56 2862.41   38.17 2933.21   38.11
 2936.31   39.05 3004.97   37.94 3023.58   39.19  3026.8   38.23 3040.41   38.23
 3149.19   39.77 3231.08   39.58 3261.49    41.1 3270.65   39.91 3310.83   39.81
 3335.34   41.07 3394.77   40.33 3442.92   43.37 3482.33   42.29 3703.61   43.78
#Mann= 3 , 0 , 0
       0     .12       0  870.35     .06       0  888.87     .12       0
#XS Ineff= 2 , 0
       0                    1200       0      40
Permanent Ineff=
       F       F
Bank Sta=870.35,888.87
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,2891    ,367.94,337.3,292.03
XS GIS Cut Line= 3
     2088020.963       130968.36      2087894.18       129763.93
     2085596.254      128305.935
#Sta/Elev= 30
       0   38.91  391.81   37.82  401.75   36.54  534.92   37.99  591.39   36.89
  626.56   34.28  814.03   34.69   829.7   32.92   833.7   34.98  908.63    34.8
  926.35   36.63  990.58   34.32  1007.4   36.57 1161.38   39.12 1356.42   37.15
 1500.41   38.95 1614.56   36.51 1793.19   38.69 2133.98   36.01 2150.98   38.64
 2475.67   37.53  2726.8      39 2960.36   36.27 3094.24   36.92 3150.73   40.35
 3218.15   41.47  3252.2    39.2 3358.87   40.63 3482.24   37.76 3932.52   41.01
#Mann= 3 , 0 , 0
       0     .12       0  814.03     .06       0   833.7     .12       0
#XS Ineff= 2 , 0
       0     550      40    1160       0      40
Permanent Ineff=
       F       F
Bank Sta=814.03,833.7
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,2554    ,705.08,616.29,557.87
XS GIS Cut Line= 3
     2088670.721      131031.751     2088068.506        129621.3
     2085675.493      128115.762
#Sta/Elev= 30
       0   39.71  101.63    39.7  144.42   36.71  216.19   36.89  260.58   39.16
  463.35   36.62  709.28   37.11  795.96   34.15 1068.41   35.08 1078.87      33
 1085.85   34.74 1134.14   35.03 1168.15   37.59 1255.37   36.12 1374.98   39.63
 1858.86   39.55 2035.67   36.65 2182.59   39.62 2377.32   39.62 2525.59   37.13
 2573.46   39.43  2579.6   38.04 2839.99   37.72 3157.15    39.6 3444.86   36.21
 3591.58   37.67 3644.85   40.25 3687.09    37.2 3860.96   37.26 4360.85   41.83
#Mann= 3 , 0 , 0
       0     .12       0 1068.41     .06       0 1085.85     .12       0
#XS Ineff= 2 , 0
       0     660      40    1400       0      40
Permanent Ineff=
       F       F
Bank Sta=1068.41,1085.85
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,1937    ,354.14,474.3,402.91
XS GIS Cut Line= 4
     2089221.329       131320.74     2089139.449      130018.848
     2088001.317      129101.792     2085700.489      128012.788
#Sta/Elev= 30
       0   34.79   705.7   34.24  714.17   36.14  893.48   36.37   930.5    34.7
  957.94   36.83 1007.01   34.68 1833.09   35.72 1977.19   33.38 1992.55   31.66
 1997.17   33.37 2245.68   32.83 2263.18   35.13 2359.42   33.19 2491.48   36.75
 2585.36   34.25 2884.07    33.5 3315.87   38.78  3429.5   38.09 3451.69   35.08
 3599.14   40.58  4279.5   36.53  4310.5   38.49  4548.3   36.58 4571.34   39.02
 4631.94   36.66 4872.86   37.22 5076.01   39.33 5107.97   41.89 5311.62   42.49
#Mann= 3 , 0 , 0
       0     .12       0 1977.19     .06       0 1997.17     .12       0
#XS Ineff= 2 , 0
       0    1350      49    2410       0      49
Permanent Ineff=
       F       F
Bank Sta=1977.19,1997.17
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,1463    ,489.6,488,431.31
XS GIS Cut Line= 4
     2089352.337      131451.748     2089401.465      129838.712
     2088312.461      128831.588     2085725.053      127816.276
#Sta/Elev= 30
       0   35.33  597.17   34.48  673.29   36.52  718.78   34.56   874.2   34.06
  901.03    35.7 1119.97   34.75 1157.52    36.6 1223.97   34.52  1483.4   35.73
 1730.14   33.64 2133.95   34.52 2638.59   33.11 2644.01   31.13 2655.25    33.1
  2940.5   34.73 2949.19   33.12 3091.49   34.46  3276.4   33.26 3302.67   34.59
 3465.47   33.18 3891.77    37.4 4301.88   36.76 4342.08   38.84 5260.89   36.29
 5505.63   39.53 5610.96   38.68 5730.82   41.23 5761.88    43.5 5876.59   42.38
#Mann= 3 , 0 , 0
       0     .12       0 2638.59     .06       0 2655.25     .12       0
#XS Ineff= 2 , 0
       0    1640      49    3110       0      49
Permanent Ineff=
       F       F
Bank Sta=2638.59,2655.25
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,975     ,481.59,499.64,473.2
XS GIS Cut Line= 4
     2089794.489      131558.192     2089892.745      129503.004
     2088402.529      128422.188     2085725.053      127693.456
#Sta/Elev= 30
       0   37.27   28.68   38.33   56.41   35.41  183.53   34.14 1225.05   35.34
 1241.97   33.85 1777.99   33.82 1861.15   35.31 2344.05   32.97  2477.1   33.33
 2508.06   35.12 2573.14   33.37 3216.53   32.89  3229.9   30.97 3236.55   33.19
 3728.61   33.88 3758.25   35.54 3846.23   33.39 4029.19   33.19 4302.45   33.46
 4373.63   35.44 4591.15    33.5  4652.5   35.07 5249.07   33.99 5476.51   37.87
  5727.1   38.48 5910.96    35.6 6357.37   37.97 6473.36   41.26 6673.31   42.76
#Mann= 3 , 0 , 0
       0     .12       0 3216.53     .06       0 3236.55     .12       0
#XS Ineff= 2 , 0
       0    2070      49    3980       0      49
Permanent Ineff=
       F       F
Bank Sta=3216.53,3236.55
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,475     ,381.2,435.06,451.38
XS GIS Cut Line= 4
     2090023.753       131566.38     2090293.957       129191.86
     2088508.973       127922.72     2085667.737      127447.816
#Sta/Elev= 30
       0   34.91   395.5   35.77  671.94   33.76  823.39   35.78  976.91   33.66
 1689.98   35.25  1844.2   33.55 1927.29   35.12 2095.05   33.22 2909.19   33.02
 3685.57   34.28 3695.53   31.87 3707.95   33.84 4534.85   35.54 4595.97   33.77
  4908.6   33.96 5172.96   35.87 5208.54   33.49 5813.56   35.19 5861.87   33.45
 5918.38    35.1 6295.98   33.97 6355.09   34.75 6367.06   36.98 6550.24   34.43
 6701.39   37.78 6771.73   36.65 7021.84   38.51 7058.43   40.62 7460.67   42.51
#Mann= 3 , 0 , 0
       0     .12       0 3685.57     .06       0 3707.95     .12       0
#XS Ineff= 2 , 0
       0    2620      49    4730       0      49
Permanent Ineff=
       F       F
Bank Sta=3685.57,3707.95
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,40      ,40.35,40.35,40.35
XS GIS Cut Line= 4
     2090253.017      131550.004     2090465.905      129159.108
     2088721.861      127316.808     2085602.233      127161.236
#Sta/Elev= 30
       0   34.51   497.6   33.94  542.48    36.4  682.16   33.66 1029.94   36.22
 1076.82   33.75 1093.95   35.23  1504.7   33.63    1673   35.25 1764.71   33.29
 2035.69   35.14 2477.55    33.1  3901.4   34.53 3907.31   31.89 3925.58   33.74
 4262.81   33.46  4350.9   36.79 4404.91   34.06 4508.76   33.57 4606.49   35.48
 4936.53   33.51 5649.01   33.51 5663.69   35.21 5783.07   33.28 6885.62   33.43
 7181.04   38.73 7374.07   37.46 7450.48   40.18 7711.51   39.25 8060.74   41.79
#Mann= 3 , 0 , 0
       0     .12       0  3901.4     .06       0 3925.58     .12       0
#XS Ineff= 2 , 0
       0    2800      49    4950       0      49
Permanent Ineff=
       F       F
Bank Sta=3901.4,3925.58
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Chan Stop Cuts=-1
Use User Specified Reach Order=0
Composite Channel Slope=5

--- SF230075BigBranch.g01 (geometry) ---

Geom Title=Big Branch into Monie Swamp
Version=September 1998 Version 2.2

River Reach=Big Branch      ,Big Branch

Type RM Length L Ch R = 1 ,15801   ,357.18,374.27,354.02
XS GIS Cut Line= 2
     2084167.119      139728.125     2081193.635      139632.889
#Sta/Elev= 30
       0   48.35  172.06   49.71  558.01   46.92  598.37    47.6  636.06   45.57
  691.28   45.27  960.72   45.83  990.94   47.14 1038.18   45.61 1240.58   45.18
 1252.17   43.11  1261.4   45.41 1496.41   47.24 1527.78   45.89 1714.93   47.22
 1742.13   46.19 1912.65   46.01 2124.49   48.01 2333.33   46.58 2428.41   48.74
 2592.63   47.76 2600.97   48.57 2609.03   47.51 2635.46   49.12 2651.82   47.65
 2743.62   49.07 2830.89   47.72 2921.67   48.83 2930.65   47.48 2975.01   47.89
#Mann= 3 , 0 , 0
       0     .12       0 1240.58     .06       0  1261.4     .12       0
#XS Ineff= 2 , 0
       0     920      49    1610       0      49
Bank Sta=1240.58,1261.4
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,15427   ,360.37,370.73,351.69
XS GIS Cut Line= 2
     2083881.411      139357.762     2081193.635      139294.271
#Sta/Elev= 30
       0   48.03  314.04   46.15  335.87   47.17  525.54   46.16  590.98   47.17
  768.16   44.34   801.4   44.62  814.25   45.88  825.38   45.16  834.88   43.45
  846.89   45.01  898.53   44.27 1108.02    46.5 1165.21   45.37 1263.73   46.12
 1266.93   44.92 1374.66   46.02 1478.01   44.88 1678.13   46.69  1842.7   45.75
 1911.13   46.83 1942.39   46.06 1965.78   47.72 2084.18   46.24 2304.15   47.83
 2356.22   46.81 2527.56   46.74 2549.16   48.19 2583.37   47.04 2688.52   47.51
#Mann= 3 , 0 , 0
       0     .12       0  825.38     .06       0  846.89     .12       0
#XS Ineff= 2 , 0
       0     740      49    1350       0      49
Bank Sta=825.38,846.89
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,15056   ,419.57,482.13,335.8
XS GIS Cut Line= 2
      2083934.32      138997.981     2081278.289      138966.236
#Sta/Elev= 30
       0   46.67    19.9   45.85   33.69   48.05  127.39   46.53  177.98   47.87
  255.69   46.07  648.13   47.17  723.59   46.75  796.39   44.24  881.86   44.24
  897.89   41.92  911.35   44.14 1019.41   45.26 1204.32   44.49 1287.24   46.05
 1413.85   44.01 1518.95   45.74 1556.81   44.88 1585.27   46.06 1743.39   44.72
 1797.57   46.11 2191.22    45.6 2324.18   47.49 2339.39   46.43 2350.03   47.47
 2397.19   46.56 2411.93   47.88 2416.89   46.49 2490.36   48.09 2656.22   47.26
#Mann= 3 , 0 , 0
       0     .12       0  881.86     .06       0  911.35     .12       0
#XS Ineff= 2 , 0
       0     880      49    1530       0      49
Bank Sta=881.86,911.35
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,14574   ,393.71,382.82,381
XS GIS Cut Line= 3
     2084071.883        138638.2     2081394.689      138669.945
     2081013.744       139050.89
#Sta/Elev= 30
       0   47.56   32.41   45.96  126.77   47.64  182.02   45.89  213.24   45.81
  223.75   47.33  417.38   45.19  531.41   46.88  661.39   45.47  744.42   47.04
  794.57   45.83  927.14   46.71 1040.29   45.46 1074.88   43.54 1344.34   43.11
 1351.79   41.18 1362.64   43.12  1618.8    45.6 1842.82   44.18 1964.58   45.99
 2023.14   44.54 2405.66   45.69 2571.53   48.04 2648.71   46.24 2810.27   47.76
  2831.5   46.15 2953.72   48.16 3083.29   46.06 3146.85   48.51 3216.12   48.12
#Mann= 3 , 0 , 0
       0     .12       0 1344.34     .06       0 1362.64     .12       0
#XS Ineff= 2 , 0
       0    1140      49    1790       0      49
Bank Sta=1344.34,1362.64
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,14191   ,350.28,349.84,346.55
XS GIS Cut Line= 3
     2083870.829      138214.928     2081511.089      138331.328
     2080897.344      139061.472
#Sta/Elev= 30
       0   46.46   37.44   47.28   79.87   45.53  204.19   45.31  288.65   46.61
   448.4   44.47  803.65   45.57  909.12   43.25 1006.88   44.71 1107.72   42.71
 1174.02   43.16 1182.96   41.25 1193.92   43.18 1800.78   44.39 1887.35   45.06
 1895.85   46.47 1900.11   45.07 2033.98   44.47 2138.31   47.03 2305.62   45.35
 2417.64   47.06 2580.93   46.31 2629.71   47.36 2703.71   45.98 2992.69    47.3
 3044.64   45.79 3116.06   47.99 3222.93   47.63 3261.13   49.25 3316.44   48.42
#Mann= 3 , 0 , 0
       0     .12       0 1174.02     .06       0 1193.92     .12       0
#XS Ineff= 2 , 0
       0    1050      49    1730       0      49
Bank Sta=1174.02,1193.92
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,13842   ,471.72,459.85,402.95
XS GIS Cut Line= 3
     2083627.448      137876.311     2081627.488      137982.129
     2080802.108      138966.236
#Sta/Elev= 30
       0   45.34   88.05   45.66  111.64   47.45   310.8   45.97  367.64   46.93
  397.64   45.27  539.77   44.52  603.26   46.65  666.16   45.17  744.77   46.17
  774.67    44.5  835.53   44.39  868.57   45.95  892.53   43.31  993.92   42.47
 1001.04   40.82 1012.45    42.5 1269.73   44.46 1694.47   44.17  1788.8   45.73
  1900.6   44.75 2219.62   46.62  2526.2   45.81 2593.24   47.56 2850.93   46.29
 2864.01   47.76 3054.88   46.46 3090.26   47.99 3106.02   46.53 3287.17   47.69
#Mann= 3 , 0 , 0
       0     .12       0  993.92     .06       0 1012.45     .12       0
#XS Ineff= 2 , 0
       0     900      49    1480       0      49
Bank Sta=993.92,1012.45
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,13382   ,534.99,557.92,279.25
XS GIS Cut Line= 3
     2083585.121      137262.567     2081437.016      137759.911
     2080643.381      138997.981
#Sta/Elev= 30
       0   46.42  108.79   48.51   271.8   46.11  452.98   47.28  704.13   45.06
  745.78   46.49  755.01   45.19  800.97   45.94  841.88   43.69  894.56   42.92
  900.01    44.4  981.37    41.9  991.18   39.92  1007.1   42.24 1102.69   43.85
  1300.2   43.03 1867.99   45.69  1996.9   44.55 2219.47   46.65 2247.22   45.56
 2268.26   46.99 2304.39   45.21 2312.09    46.7 2319.02    45.5 2466.28   45.71
 2513.81   47.31 2812.43   45.81 2888.97   48.04 3482.93   46.34 3675.53   49.23
#Mann= 3 , 0 , 0
       0     .12       0  981.37     .06       0  1007.1     .12       0
#XS Ineff= 2 , 0
       0     860      49    1470       0      49
Bank Sta=981.37,1007.1
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,12824   ,376.68,382.44,345.9
XS GIS Cut Line= 3
     2083415.812       136871.04     2081437.016      137611.766
     2080569.309      138913.327
#Sta/Elev= 30
       0    46.5  236.29   43.74  272.38    46.2  371.49   45.87  407.57   43.19
  467.58   44.42  479.45   41.17   500.1   41.25   517.8   38.82  523.07   41.22
   640.3   42.09  657.47   44.13  850.75   44.93  980.05   43.07 1375.15    45.3
 2197.58   44.66 2340.43   47.54 2367.14   45.45 2710.73   47.42 2856.31   45.68
 2920.69   48.04 2975.53   46.67 3290.06   47.44 3340.22   49.62 3441.21   45.84
 3508.51   49.05 3528.13   47.71 3540.46   50.07 3553.65   47.06 3677.17   47.79
#Mann= 3 , 0 , 0
       0     .12       0   500.1     .06       0  523.07     .12       0
#XS Ineff= 2 , 0
       0     480      49    1340       0      49
Bank Sta=500.1,523.07
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,12441   ,466.29,724.22,1026.16
XS GIS Cut Line= 4
     2084112.306      136941.388      2083028.73      136616.315
     2081484.634      137326.057     2080414.603       138902.66
#Sta/Elev= 30
       0   47.29   43.27   49.39  436.09    45.7  511.64   47.67  771.43   47.47
  821.31   45.49 1031.86   44.51 1072.82   45.94 1340.32   42.05 1352.08   39.71
 1359.26   41.51 1541.95   43.82 1704.71   42.48 2319.99   45.18 2472.61   43.76
 2736.55   46.02 2994.52   44.63 3329.64   46.92 3334.29   45.18 3765.71   48.47
 3787.41   45.83 3975.94   49.78 4075.28   47.17 4296.38   47.44 4344.75   48.53
 4365.68   51.57 4534.13   48.44 4587.98   51.91 4679.16   46.81 4736.11   49.87
#Mann= 3 , 0 , 0
       0     .12       0 1340.32     .06       0 1359.26     .12       0
#XS Ineff= 2 , 0
       0    1340      49    2030       0      49
Bank Sta=1340.32,1359.26
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,11717   ,501.46,496.69,449.9
XS GIS Cut Line= 4
     2084104.724      136900.992     2083077.736      136594.229
     2082397.524      135540.567      2080397.52      135540.567
#Sta/Elev= 30
       0   48.46  138.97   48.28  163.59    46.2  257.26   45.88  348.27   47.29
  375.94   45.49  503.23   47.58  648.49   46.47  710.46   49.77  732.23   49.52
  739.93    46.5  795.81   44.32  975.25   45.87 1005.32   43.68  1009.5   45.28
 1234.74   43.14 1341.02   45.68 1468.56   42.06 1509.01   44.16 1632.83   42.81
 1643.23   39.26 1648.82   42.41 1656.09   42.88 1697.55   42.92 1758.17    39.8
  1848.5   40.58 1923.31   45.25 2162.76   49.81 2316.81   48.02    4325      50
#Mann= 3 , 0 , 0
       0     .12       0 1632.83     .06       0 1656.09     .12       0
#XS Ineff= 2 , 0
       0    1390      49               0
Bank Sta=1632.83,1656.09
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,11221   ,441.99,445.57,438.23
XS GIS Cut Line= 2
     2083516.486      136555.411     2082608.602      135025.823
#Sta/Elev= 30
       0   45.29  111.59   46.13  122.79   47.67  181.28   44.75   247.7   45.02
   268.4   43.55  294.29   45.53  396.49   44.67  412.99    46.7  427.37   45.29
  430.98   46.36  470.97   44.33  553.26   45.12  642.01   42.46  741.37   43.18
  746.62    41.7  775.78   43.36  893.88   40.36  996.43   40.82 1010.09   39.41
 1014.19    37.5 1028.11   39.29 1100.46   41.67  1138.9   44.92 1171.43   44.33
 1262.64    46.4 1416.08    45.8 1422.68    44.9 1576.66      48 1778.73   47.43
#Mann= 3 , 0 , 0
       0     .12       0 1010.09     .06       0 1028.11     .12       0
#XS Ineff= 2 , 0
       0     780      44               0
Bank Sta=1010.09,1028.11
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,10775   ,398.15,410.32,395.78
XS GIS Cut Line= 2
     2083835.562      136213.309     2082980.308      134818.588
#Sta/Elev= 30
       0   52.23  329.36   45.18  507.36   43.34  521.72   42.16  586.13   42.53
   593.6   43.34  596.92   42.56   605.8   43.59  610.68   42.33  622.92   42.39
  656.23   43.74  673.02   41.37  678.07   41.74  698.31   40.33  747.03   42.21
  757.35   41.63  761.26   42.87  770.17   41.25  826.21   41.59  835.18   39.21
  836.28   37.98  847.48   41.22  868.54   39.32  892.57   38.88  969.97   39.56
 1038.93   39.01 1209.84   41.69 1270.11   43.72 1320.42   43.39 1636.06   46.79
#Mann= 3 , 0 , 0
       0     .12       0  826.21     .06       0  847.48     .12       0
#XS Ineff= 2 , 0
       0     660      44               0
Bank Sta=826.21,847.48
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,10365   ,390.75,390.69,388.1
XS GIS Cut Line= 2
     2084141.479      135940.286     2083338.857      134657.406
#Sta/Elev= 30
       0      52  239.26   46.44  391.09    44.2  394.78   44.71  444.34   41.78
  453.13      43  480.68   42.19  504.11   42.76  517.51   44.79  532.36   45.82
   573.5    45.6  665.35   39.13  675.75   38.92   683.2   39.84  694.59   39.11
  707.47   36.95  714.26   38.94  777.72   40.44  803.56   42.14  818.09   44.41
   842.4   42.13   924.1   41.33   935.7   39.97  955.08   39.24 1029.59   38.82
 1083.71   41.07 1113.85   43.37 1182.43   43.18 1406.06   46.98 1513.27   47.17
#Mann= 3 , 0 , 0
       0     .12       0  694.59     .06       0  714.26     .12       0
#XS Ineff= 2 , 0
       0     550      47               0
Bank Sta=694.59,714.26
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,9974    ,472.03,597.72,448.55
XS GIS Cut Line= 2
     2084357.518      135541.142     2083668.981      134466.232
#Sta/Elev= 30
       0    48.9   77.08   48.41  119.04    46.2  148.59   45.81  186.22   42.81
  262.42   43.02  267.18   41.66  287.84   41.17  324.47   43.04  380.48   40.99
  400.16   38.87  450.61   38.77  460.25   36.58  469.26   38.73  471.04   39.94
  482.67   41.01  504.92   39.49  522.27   40.27  530.04   39.03  558.08   38.03
  639.84   38.42  680.27   40.14  704.29   38.98  784.24   40.19  806.51   41.07
  811.24   42.52  833.14   43.79  912.94   44.26 1050.02   47.18 1276.52   47.43
#Mann= 3 , 0 , 0
       0     .12       0  450.61     .06       0  469.26     .12       0
#XS Ineff= 2 , 0
       0     330      44               0
Bank Sta=450.61,469.26
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,9376    ,357.14,392.85,319.59
XS GIS Cut Line= 2
     2084719.123      135204.304        2084020.         134248.
#Sta/Elev= 30
       0   46.17    9.99   46.62   17.37   45.56   34.52   45.11   43.73   44.16
   84.01   43.79   93.73   42.99  137.44    41.8  149.39   40.75  184.47   41.07
  224.75   40.37   259.1   38.93  292.94   38.94  313.86   37.86  347.09   37.74
  356.44   35.89  367.23   37.94  431.04   37.88  470.48   39.59  501.39   39.38
  525.88   38.13  626.34   38.11  657.41   39.33  728.32   40.69  744.17   40.91
  749.96   39.59  755.53   39.61  764.39   40.74  1051.6   43.46 1184.61   45.97
#Mann= 3 , 0 , 0
       0     .12       0  347.09     .06       0  367.23     .12       0
Bank Sta=347.09,367.23
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,8983    ,282.09,304.03,307.4
XS GIS Cut Line= 2
     2085159.985      135110.187     2084199.005      134064.998
#Sta/Elev= 30
       0   49.35   96.68   47.74  227.12   44.18  341.79   42.05  388.95   42.03
  422.16   39.99  436.46   41.35  438.89   40.76  453.27   41.22  467.94   39.18
  483.76   38.62  496.36   39.52   527.9   38.38   568.4   38.22  571.72   38.93
  577.31   37.69  599.17   36.78  603.31   36.54  608.16   35.37  620.46    37.6
  735.95   37.06  821.92   37.76  858.69   37.26  914.53   38.68  946.51   40.14
  960.32   41.37  969.57   40.83 1010.77   40.89 1328.26   45.65 1419.82   45.16
#Mann= 3 , 0 , 0
       0     .12       0  599.17     .06       0  620.46     .12       0
Bank Sta=599.17,620.46
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,8679    ,388.59,370.42,370
XS GIS Cut Line= 2
     2085328.404      135025.978     2084456.588      133747.974
#Sta/Elev= 30
       0   51.77  140.14   49.31  339.64    43.5  403.89   42.28  441.32   42.63
  469.02   40.64  493.75   40.95  507.38   39.46  577.31   37.95  588.55   38.53
  641.97   38.68  682.04    37.9  696.16   39.09   704.9   37.42  748.77   36.54
  761.19   34.56  770.43   36.75  830.29    36.9  850.52   37.64   854.6   38.94
   866.6   37.67   877.1   39.21  901.15   40.02  936.04   39.79  966.63   38.71
 1040.94   39.82 1081.25    41.9 1113.51   41.21 1336.46   44.08 1547.05   43.28
#Mann= 3 , 0 , 0
       0     .12       0  748.77     .06       0  770.43     .12       0
Bank Sta=748.77,770.43
Exp/Cntr=.5,.3

Type RM Length L Ch R = 1 ,8309    ,95.66,101.38,99.99
XS GIS Cut Line= 6
 2085619.3903802   134798.486968 2085619.3903802   134778.486968
     2085442.936      134585.906      2085321.41      134425.713
      2085165.36      134163.329 2084765.9994602   133575.796858
#Sta/Elev= 30
       0   49.19   88.65   46.77  136.05   47.37     233   46.43  321.73   44.13
  375.44    45.1  392.61   42.03  401.61    41.6  442.72   41.92  463.86   40.43
   509.3      40  523.06   39.06  616.91   39.13  678.68   40.21  691.92   38.99
  703.94    39.5  733.54   38.19  853.56   37.74     860    32.5     878    32.5
  880.94   38.33  913.58   36.92   936.6   39.56  954.08   40.05 1033.16    39.4
 1184.13   40.43 1210.62   42.32 1254.66   41.54 1326.17   42.75 1499.41   41.03
#Mann= 3 , 0 , 0
       0     .12       0  853.56     .06       0  880.94     .12       0
#XS Ineff= 2 , 0
       0     620      42    1190       0      42
Bank Sta=853.56,880.94
Exp/Cntr=.5,.3

Type RM Length L Ch R = 2 ,8278    ,,,
BEGIN DESCRIPTION:
SR 1114 -- Columbus County Small Pipe 23 2006
END DESCRIPTION:
Bridge Culvert--1,0,-1,-1, 0
Deck Dist Width WeirC Skew NumUp NumDn MinLoCord MaxHiCord MaxSubmerge Is_Ogee
18,25,2.6,0,126,126,,,.95,0,0,0,,
       0    4.27    13.9   19.63   41.13   54.89   64.27   72.81    97.8  114.16
  127.48  133.18  141.15  146.65  150.43  162.18  165.13  179.76  188.49  195.52
  199.64  204.74  213.29  221.14  226.13  235.17  245.68  254.51  261.99  263.97
  270.41  277.89  283.33  299.79  310.57   315.2  322.77  324.96  334.75  337.39
  350.11  359.91   368.6  371.61  381.91  394.56  401.61  414.33  421.78  429.87
  434.46  442.69  443.56  452.07  460.08  465.89  480.13  483.19  485.24  509.23
  520.56  527.74  530.66  544.12  551.47  554.55  564.48   570.8  585.37  594.37
  603.51  607.01  610.83  631.12  632.41  656.44  688.08   804.6  915.59   987.9
 1031.28 1071.86  1084.1 1096.12 1102.82 1113.65 1124.96 1142.93 1150.68 1160.78
  1167.3 1174.95 1181.93 1192.17 1198.03 1210.17  1217.2 1228.61 1240.04 1252.18
 1268.19 1275.53 1295.25 1306.07 1315.29  1330.7 1342.15 1350.06 1354.21 1376.62
 1388.81 1398.03 1405.93 1414.68 1421.31 1433.47 1438.52 1449.92 1454.22 1462.32
 1463.52 1468.97 1475.94 1493.06 1502.37 1504.85
   47.07   47.01   46.93   46.91   46.75   46.69   46.52   46.37   46.37   46.01
   46.03   46.12   46.06   46.01   45.87   45.75   45.69   45.62   45.49   45.44
   45.51   45.48   45.46   45.36   45.25   45.14   44.94   44.78   44.71   44.77
   44.83    44.7   44.56   44.42    44.4   44.26   44.19   44.12   44.04   43.97
   43.85   43.71   43.01   42.84   42.91   42.69   42.89   42.92   42.59   42.78
    42.7   42.49   42.44   42.48   42.39   42.22   42.13   42.04   41.96   41.68
   41.63   41.49   41.44   41.06   41.07   41.22   41.31    41.3   41.09   41.09
   40.98   40.91   40.72   40.45   40.37   40.12   40.05   40.04    40.1   40.14
   40.21   40.38   40.45   40.49   40.44    40.3   40.34   40.41   40.42   40.34
   40.38   40.46    40.5   40.45   40.41   40.36    40.3   40.36    40.4   40.43
   40.33   40.39   40.46   40.36   40.36   40.38   40.26   40.28   40.37   40.47
   40.45   40.47   40.42   40.34   40.32   40.29   40.22   40.26   40.31    40.3
   40.43   40.49   40.16   40.18   40.25   40.29
       0    4.27    13.9   19.63   41.13   54.89   64.27   72.81    97.8  114.16
  127.48  133.18  141.15  146.65  150.43  162.18  165.13  179.76  188.49  195.52
  199.64  204.74  213.29  221.14  226.13  235.17  245.68  254.51  261.99  263.97
  270.41  277.89  283.33  299.79  310.57   315.2  322.77  324.96  334.75  337.39
  350.11  359.91   368.6  371.61  381.91  394.56  401.61  414.33  421.78  429.87
  434.46  442.69  443.56  452.07  460.08  465.89  480.13  483.19  485.24  509.23
  520.56  527.74  530.66  544.12  551.47  554.55  564.48   570.8  585.37  594.37
  603.51  607.01  610.83  631.12  632.41  656.44  688.08   804.6  915.59   987.9
 1031.28 1071.86  1084.1 1096.12 1102.82 1113.65 1124.96 1142.93 1150.68 1160.78
  1167.3 1174.95 1181.93 1192.17 1198.03 1210.17  1217.2 1228.61 1240.04 1252.18
 1268.19 1275.53 1295.25 1306.07 1315.29  1330.7 1342.15 1350.06 1354.21 1376.62
 1388.81 1398.03 1405.93 1414.68 1421.31 1433.47 1438.52 1449.92 1454.22 1462.32
 1463.52 1468.97 1475.94 1493.06 1502.37 1504.85
   47.07   47.01   46.93   46.91   46.75   46.69   46.52   46.37   46.37   46.01
   46.03   46.12   46.06   46.01   45.87   45.75   45.69   45.62   45.49   45.44
   45.51   45.48   45.46   45.36   45.25   45.14   44.94   44.78   44.71   44.77
   44.83    44.7   44.56   44.42    44.4   44.26   44.19   44.12   44.04   43.97
   43.85   43.71   43.01   42.84   42.91   42.69   42.89   42.92   42.59   42.78
    42.7   42.49   42.44   42.48   42.39   42.22   42.13   42.04   41.96   41.68
   41.63   41.49   41.44   41.06   41.07   41.22   41.31    41.3   41.09   41.09
   40.98   40.91   40.72   40.45   40.37   40.12   40.05   40.04    40.1   40.14
   40.21   40.38   40.45   40.49   40.44    40.3   40.34   40.41   40.42   40.34
   40.38   40.46    40.5   40.45   40.41   40.36    40.3   40.36    40.4   40.43
   40.33   40.39   40.46   40.36   40.36   40.38   40.26   40.28   40.37   40.47
   40.45   40.47   40.42   40.34   40.32   40.29   40.22   40.26   40.31    40.3
   40.43   40.49   40.16   40.18   40.25   40.29
Multiple Barrel Culv=2,5,6,40,.017,.4,1,8,1,32.5,32, 2,Culvert #1  , 0 ,30
     865     865     875     875
BC Design=,, 0 ,, 0 ,,,,,,

Type RM Length L Ch R = 1 ,8208    ,193.25,183.24,123.87
XS GIS Cut Line= 6
     2085694.077      134723.594     2085507.293      134490.596
     2085335.914        134265.3      2085083.66      133887.881
     2084906.504      133637.553        2084760.         133548.
#Sta/Elev= 30
       0   46.65   94.24   47.06  151.06   45.68  233.41    45.5  352.97   43.02
  386.86   40.49  412.93   40.61  435.25   42.71  480.27   40.36  540.64   39.33
  590.28   39.95  640.67   38.76  646.68    39.5  654.66   38.38  667.25   38.89
  690.63   37.29  762.95   38.51  810.35   37.45  837.31    38.6  858.69   37.99
     860      32     880      32  883.24   36.95  905.07   37.94  945.66   37.43
  972.15   39.53 1147.53   40.76 1349.79   40.53 1362.71   39.81 1514.03   40.62
#Mann= 3 , 0 , 0
       0     .12       0  858.69     .06       0  883.24     .12       0
#XS Ineff= 2 , 0
       0     625      42    1100       0      41
Bank Sta=858.69,883.24
Exp/Cntr=.5,.3

Type RM Length L Ch R = 1 ,8024    ,112.22,91.51,70.35
XS GIS Cut Line= 5
     2085880.877      134351.918     2084924.985       133633.38
     2084824.433      133581.767      2084576.71      133366.788
      2084276.71      133366.788
#Sta/Elev= 30
       0   45.52   91.04   45.33  160.07   43.54  280.63   44.04  288.85   42.59
  327.43   42.29  345.89   40.78  418.03   40.23  429.95   41.27  515.57   39.15
  630.02   37.89  661.26   38.83  754.05   36.72  797.15   38.04  810.49   29.91
   821.7   37.58  833.25   36.69   905.8   36.44  921.08    39.3  930.54   38.51
 1078.04   41.01 1244.05   40.02 1401.28   40.72 1428.39   39.83 1433.03   37.96
 1443.59   39.72 1489.13   40.48 1532.12   40.59 1547.44   39.61 1936.86      41
#Mann= 3 , 0 , 0
       0     .12       0  797.15     .06       0   821.7     .12       0
#XS Ineff= 2 , 0
       0     680      40    1020       0      42
Bank Sta=797.15,821.7
Exp/Cntr=.5,.3

Type RM Length L Ch R = 1 ,7933    ,104.18,106.99,105.91
XS GIS Cut Line= 6
        2086000.         134114.     2084843.082      133585.337
     2084767.452      133522.311     2084683.417      133389.957
     2084628.795      133259.704     2084601.484      133030.711
#Sta/Elev= 30
       0   46.13   53.38   45.62   77.43   46.72  170.79   46.09  260.36   44.55
  385.33    40.2  472.52   39.94  497.48   38.18  531.05   39.22   553.3   38.28
  573.16   39.17  651.33   36.99     778    36.7  793.52   35.82  805.19   29.37
  811.68   36.27   820.3   36.98   878.6   36.38  937.31   39.03  966.45   38.45
 1170.91   40.26 1376.11   40.82  1468.5      40 1488.11   38.83 1662.44   40.04
 1824.14   38.49 1840.46   38.84 1846.78   39.92 1855.03   39.38  1899.1   40.51
#Mann= 3 , 0 , 0
       0     .12       0     778     .06       0   820.3     .12       0
#XS Ineff= 2 , 0
       0     748      40    1078       0      40
Bank Sta=778,820.3
Exp/Cntr=.5,.3

Type RM Length L Ch R = 3 ,7890    ,,,
BEGIN DESCRIPTION:
SR 1006 -- Columbus County Bridge #75
END DESCRIPTION:
Bridge Culvert--1,0,-1,-1, 0
Deck Dist Width WeirC Skew NumUp NumDn MinLoCord MaxHiCord MaxSubmerge Is_Ogee
30,25,2.6,0,91,91,,,.95,0,0,0,,
       0    3.32    34.4   41.46   48.03    55.1   63.51   82.87   89.07   98.83
  101.47  109.48  121.76  156.83  164.04  176.57  183.83  195.45  199.94  213.26
  222.47  235.75  240.87  248.93  250.16  252.44   263.4   275.9  290.94  302.66
   311.6  314.71     329  331.75  334.54  349.52  351.93  357.87  359.72  393.32
  417.17  440.27  449.67  489.66  514.92  527.78   588.8  616.94  666.22  712.08
  737.31     780     780  796.94     817     817  847.39  873.77  909.32  989.58
 1026.28 1069.85 1115.72 1152.41 1199.59 1208.69 1241.18 1246.79    1256 1266.15
 1280.25 1296.03 1324.15 1383.71  1410.7 1439.73 1554.62  1567.7 1584.36 1624.13
 1637.47 1681.46 1705.62 1711.22 1723.42 1724.18  1729.4 1735.44  1741.7 1754.39
 2051.62
    45.8   45.72    45.5   45.42    45.4   45.28   45.33   45.17   45.17   45.04
   44.97   44.89    44.8   44.42   44.32   44.24   44.16   44.13   44.02   43.85
   43.79   43.83   43.89   43.85   43.79   43.64   43.53   43.37   43.01    42.8
   42.71   42.65   42.53   42.44    42.3    42.1   41.98   41.86    41.8   41.34
   41.07   40.92   40.91   40.78   40.66   40.54   40.32   40.24   40.06   39.91
   39.79   39.67   39.67    39.6   39.57   39.57   39.51   39.48   39.47   39.48
   39.49   39.49   39.55   39.61   39.68   39.72   39.86   39.84   39.95   40.03
   40.19   40.38   40.44   40.63   40.63   40.67    40.8    40.8   40.82   40.86
   40.86    40.8   40.76   40.72   40.66    40.6   40.49   40.46   40.39   40.33
   39.85
                      38      38      38
       0    3.32    34.4   41.46   48.03    55.1   63.51   82.87   89.07   98.83
  101.47  109.48  121.76  156.83  164.04  176.57  183.83  195.45  199.94  213.26
  222.47  235.75  240.87  248.93  250.16  252.44   263.4   275.9  290.94  302.66
   311.6  314.71     329  331.75  334.54  349.52  351.93  357.87  359.72  393.32
  417.17  440.27  449.67  489.66  514.92  527.78   588.8  616.94  666.22  712.08
  737.31     780     780  796.94     817     817  847.39  873.77  909.32  989.58
 1026.28 1069.85 1115.72 1152.41 1199.59 1208.69 1241.18 1246.79    1256 1266.15
 1280.25 1296.03 1324.15 1383.71  1410.7 1439.73 1554.62  1567.7 1584.36 1624.13
 1637.47 1681.46 1705.62 1711.22 1723.42 1724.18  1729.4 1735.44  1741.7 1754.39
 2051.62
    45.8   45.72    45.5   45.42    45.4   45.28   45.33   45.17   45.17   45.04
   44.97   44.89    44.8   44.42   44.32   44.24   44.16   44.13   44.02   43.85
   43.79   43.83   43.89   43.85   43.79   43.64   43.53   43.37   43.01    42.8
   42.71   42.65   42.53   42.44    42.3    42.1   41.98   41.86    41.8   41.34
   41.07   40.92   40.91   40.78   40.66   40.54   40.32   40.24   40.06   39.91
   39.79   39.67   39.67    39.6   39.57   39.57   39.51   39.48   39.47   39.48
   39.49   39.49   39.55   39.61   39.68   39.72   39.86   39.84   39.95   40.03
   40.19   40.38   40.44   40.63   40.63   40.67    40.8    40.8   40.82   40.86
   40.86    40.8   40.76   40.72   40.66    40.6   40.49   40.46   40.39   40.33
   39.85
                      38      38      38
Pier Skew, UpSta & Num, DnSta & Num=,798, 2 ,798, 2 , 0 , 0 , 0 ,,
       2       2
      25      39
       2       2
      25      39
BR Coef=-1 , 1 , 0 ,, 0 ,,,.8,0,1.2,0,
WSPro=,,,, 1 ,,,, 0 ,,,, 0 ,,,,-1 ,-1 ,-1 , 0 , 0 , 0 , 0 , 0
BR U #Sta/Elev= 230
       0   46.13    3.85   46.04   25.79   45.86   32.04   45.77   38.87   45.73
   44.92   45.75   47.36   45.69   53.38   45.62   63.03   45.86   64.12   45.95
   66.15   46.41   71.28   46.66   77.43   46.72   84.61   46.54   91.46   46.45
  110.71    46.4  122.31   46.18  132.39   46.18   137.9    46.2  147.43   46.13
  170.79   46.09  179.18   45.94  182.45   45.78  190.44   45.54  218.13    45.1
  226.14   45.04  230.62   44.92  237.28   44.83  243.32   44.82  260.36   44.55
  260.97   44.49  270.33   44.18  274.06   44.09  278.75   43.86  288.86   43.44
   306.4   42.91     325   42.16  330.75   42.05  333.76    41.8  346.74   41.33
  355.85   41.15   357.9   41.01   370.9   40.79  377.29   40.61  379.61   40.51
  383.28   40.29  385.33    40.2  394.76   40.07  397.82      40  409.42   39.84
  416.23   39.83  418.43   39.92  420.52    39.8  427.03   40.54  436.33   40.02
  438.36   39.71  445.16   39.88  459.26   39.71  464.87   39.85  472.52   39.94
  495.76   38.29  497.48   38.18  508.46   38.14  515.99   38.44  520.52   38.95
   526.6   39.13  531.05   39.22  533.52   39.17   553.3   38.28  568.88   39.06
  573.16   39.17  577.37   39.08  582.52   38.84  595.45   38.33  609.03   38.38
  618.09   38.32  621.29   38.02  629.97   37.56  631.36   37.64  639.39   37.53
  651.33   36.99  654.44   37.07  669.58   37.02  672.24   37.31  673.11   37.37
  673.31   37.45  681.39   37.49  683.71   37.36  694.72   37.17  706.99   37.13
  715.17   37.23   722.1   37.38  726.13   37.21   733.2   37.08  752.23   36.73
  758.35   36.69  764.62   36.92  767.47   37.05     778    36.7  787.26   36.07
  793.52   35.82  805.19   29.37  811.68   36.27  813.86   36.69   820.3   36.98
  825.37   36.62  829.63   36.69  836.86   36.71  842.46   36.86  846.15   36.76
  851.73   36.53   861.7   36.81  866.42   36.42  867.52   36.34   878.6   36.38
   888.9   36.68  902.52   37.25   917.4   37.98  923.84   38.67  934.43   38.97
  937.31   39.03  953.59   38.73  966.45   38.45  971.31   38.56  980.44   38.57
  989.99   38.67  995.13   38.81 1002.38   38.85 1010.47    39.2 1024.43   39.43
 1030.44   39.39 1039.58   39.33 1049.36   39.42 1060.19   39.58 1071.06   39.56
 1072.66   39.62 1078.85   39.78 1085.08   39.85 1088.07   39.92 1115.83   40.04
 1140.05   39.96 1143.47   40.08 1160.93   40.16 1163.77   40.22 1170.91   40.26
 1183.45   40.11 1194.54   40.17 1197.99   40.26 1217.89   40.35 1227.71   39.93
 1233.94    39.9 1249.62   40.08 1251.25   40.14 1265.53   40.25 1271.04   40.23
 1276.58   40.24 1285.26   40.06 1295.73   40.07  1302.4   40.16 1310.68   40.19
 1323.66   40.46 1339.18    40.6 1355.28   40.69 1363.02   40.71 1370.47   40.82
 1376.11   40.82 1380.18   40.75 1386.82   40.72 1389.72   40.64 1402.46   40.23
 1406.27   40.04 1431.37   40.17 1432.02   40.02 1432.47   39.95 1434.63   40.04
  1441.2   39.71 1446.98   39.97 1448.31   40.09 1457.66   40.07 1462.77   40.09
  1468.5      40 1480.21    39.4 1482.62   39.33 1488.11   38.83  1490.3   38.99
 1495.11   39.21 1499.92   39.27 1507.46   39.21 1512.89   39.23 1527.25   39.33
 1532.73   39.37 1544.59   39.51 1550.36   39.61 1562.88    39.7 1566.28   39.76
  1579.3   39.74 1601.53   39.82 1607.84   40.02 1613.63   40.03 1619.46   39.87
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BR U #Mann= 3
       0     .12     778     .05   820.3     .12
BR D #Sta/Elev= 242
       0   45.53    6.43   45.54   15.65   45.66   42.18   45.67   51.44    45.6
   54.84   45.65   67.21   45.68   76.05   45.64  107.99   45.63  121.15   45.57
  127.41   45.75  128.71   45.82  136.27   45.97  143.47   45.79  148.47   45.56
  150.66   45.49  158.59   45.47  165.74   45.54  183.65   45.46  205.16   45.27
  209.18   45.17  225.23   44.69  226.48   44.63  232.76   44.27   235.3   44.17
  244.86   43.88  257.51   43.62  265.85   43.52  271.58   43.38  294.69   42.91
  309.91   42.42  311.29   42.32  326.97   41.91  332.75   41.85  336.61   41.71
  350.63   41.55  354.11   41.45  355.77   41.37  364.18   41.14  367.26   41.04
  373.32   40.92  385.56   40.81  389.69   40.73  402.12   40.47  421.57   40.26
  439.73   40.48  443.53   40.54  449.15    40.5  454.41   40.52  478.08   39.98
  479.93   39.71  491.96   39.74  502.43   38.99  510.94   38.12     522   38.53
  530.38   38.47  543.16   37.93  547.61   37.68  549.72   37.94  559.51    36.9
  565.15   37.09  568.44   37.25  581.65   36.83  588.59   37.67   592.8   37.74
  599.86   37.59  601.94   37.41  609.09   36.89  620.85   36.95  631.05    36.7
  644.42   36.64  661.72   36.79  672.58   36.85  675.01   36.76   678.5   36.52
  681.26   36.45  689.22   36.57  698.03   36.59  701.65   36.72  708.14   36.95
     728   37.11   734.2   37.29  742.46   37.47  749.53   37.53  757.11   37.42
  765.96   37.13  779.25    37.1  785.32   36.35   795.4   35.69  804.22   29.17
  811.65   35.32  814.27   36.24   821.3   36.92  825.65   36.81  833.98   36.62
  839.92    36.6  852.52   36.74  862.96   36.71  873.27   36.72  881.71   37.03
  883.19   37.13  884.88    37.2  896.68   37.16  901.23   37.25  908.19   37.27
  917.24   37.78  918.91   37.84  923.98   37.95     935   38.03  940.24   37.98
  952.49   37.99  967.02    38.2  983.02   38.73 1019.52   38.56  1041.4   38.33
 1044.15   38.27 1055.25   38.17 1062.83   38.16 1065.06   38.22 1071.81   38.29
 1076.08    38.6 1084.42   38.58 1089.43   38.28 1094.46   38.37 1100.87   38.38
 1101.53   38.19 1104.94   38.32 1110.33   38.42 1116.73   38.66 1119.05   38.72
 1122.77   38.63 1135.06    38.1 1139.02   38.28 1140.07   38.16 1148.32   38.06
 1150.15   38.14  1160.8   38.71 1162.49   38.78 1164.36   38.67  1168.2   38.58
 1173.97   38.56 1177.39   38.47  1179.6   38.53 1185.97   38.42 1189.35   38.26
 1190.24   38.15 1194.57   38.23 1196.74   38.48 1199.62   38.57 1210.45   38.65
 1214.17    38.6 1224.86   38.48 1243.74   38.76 1255.95   38.65 1265.17   38.42
 1272.42    38.4 1278.06   38.59 1291.65   38.56  1297.6   38.43 1309.85    38.6
 1318.07   38.48  1346.8   39.04 1360.07   39.27 1380.71    39.3  1381.5   39.37
 1390.39   39.33 1401.87   39.07  1409.4      39 1414.58   39.02 1420.09   39.11
 1425.67   39.15 1434.19   39.34  1442.5   39.46 1452.68   39.39  1456.5   39.31
 1462.35   39.27 1467.46   38.85 1476.47   38.75 1481.36   38.65 1487.64   38.62
 1501.14   38.42 1508.04   38.67 1526.01   38.68 1530.63   38.61 1539.65   38.67
  1544.9   38.68 1548.89    38.8 1565.24      39 1571.63   38.96 1578.07   39.09
 1582.29   39.27 1595.92   39.79 1598.04   39.91    1610   39.59 1612.61   39.43
 1618.28   39.03 1626.46   39.06 1632.72   39.18 1641.32   39.17 1647.97   39.09
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BR D #Mann= 3
       0     .12  779.25     .05   821.3     .12
BC Design=,, 0 ,, 0 ,,,,,,

Type RM Length L Ch R = 1 ,7826    ,367.06,401.59,406.65
XS GIS Cut Line= 6
     2086045.436      134023.284     2084788.426       133431.48
     2084740.256       133353.49     2084698.967      133218.155
        2084690.         132995.        2084590.         132932.
#Sta/Elev= 30
       0   45.53  205.16   45.27  373.32   40.92  491.96   39.74  510.94   38.12
  530.38   38.47  559.51    36.9   592.8   37.74  681.26   36.45  779.25    37.1
   795.4   35.69  804.22   29.17  811.65   35.32   821.3   36.92  873.27   36.72
  983.02   38.73 1148.32   38.06 1162.49   38.78 1190.24   38.15  1442.5   39.46
 1501.14   38.42 1598.04   39.91 1721.72   38.16 1774.58   38.46 1824.39   36.89
  1841.4   38.78 1867.97   39.39 1926.05   38.68  1936.8   40.07 1964.66   40.47
#Mann= 3 , 0 , 0
       0     .12       0  779.25     .06       0   821.3     .12       0
#XS Ineff= 2 , 0
       0     748      40    1078       0      40
Bank Sta=779.25,821.3
Exp/Cntr=.5,.3

Type RM Length L Ch R = 1 ,7424    ,311.06,336.93,285.95
XS GIS Cut Line= 2
     2086365.103      133949.864     2084209.509      132477.097
#Sta/Elev= 30
       0   44.24  174.23   43.09  211.64   44.31  391.46    42.6  478.75   38.54
  559.36    37.6  678.12   37.81  736.74    39.8   769.9   37.25  820.63   35.85
  984.22   37.01  989.26   36.02  993.89   31.57  999.44   36.09  1002.5   36.49
 1172.43   37.11 1354.47   35.62 1473.66   35.97 1488.87   37.18 1496.64    35.9
 1616.78    35.8 1697.88   37.27 1730.81   36.03 1902.86   37.34 1931.41   36.45
 2049.91   37.79 2109.25   39.94 2125.39   38.92 2188.51   39.32 2610.68   44.87
#Mann= 3 , 0 , 0
       0     .12       0  984.22     .06       0  1002.5     .12       0
#XS Ineff= 2 , 0
       0     830      40    1690       0      40
Bank Sta=984.22,1002.5
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,7087    ,481.02,477.52,433.57
XS GIS Cut Line= 2
     2086793.544      133876.225     2084082.315      132068.739
#Sta/Elev= 30
       0   45.17  395.04   43.27  526.98   41.39  562.59   39.53  584.22   40.96
  611.46   38.69  699.74   36.89  857.71   36.36  904.31   37.38  910.39   35.91
  980.09    36.7 1290.36   35.48 1300.43   33.29 1313.17    35.4 1461.77   36.42
 1869.08   35.32 2211.23   36.19 2275.77   37.25 2287.48   36.29 2337.17   36.35
 2456.53   37.08  2482.5   38.87 2507.91   38.39 2539.17   40.45 2597.89    40.4
 2630.96   38.94 2639.88   39.02 2645.48   41.04 2812.79   42.49 3258.49   43.58
#Mann= 3 , 0 , 0
       0     .12       0 1290.36     .06       0 1313.17     .12       0
#XS Ineff= 2 , 0
       0    1080      40    1980       0      40
Bank Sta=1290.36,1313.17
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,6610    ,457.44,508.09,438.82
XS GIS Cut Line= 2
     2087307.813      133725.872     2084154.107      131570.575
#Sta/Elev= 30
       0      45  386.88   44.55  529.64      43  724.95   38.15  839.29   38.77
  860.98   37.27 1127.51   37.65 1284.78   35.33 1539.39   35.16 1552.85   33.49
 1569.95    35.5 2227.36   35.78 2324.02   37.46 2339.31   36.23 2411.13   36.01
 2453.46   37.64 2467.36   36.07 2550.33   37.45 2655.43   36.24 2706.44   36.38
 2713.95   37.99 2716.78   36.56 2801.78   36.57 3125.99   39.48 3253.53   42.68
 3282.55   42.23 3296.47   40.35 3307.56    42.1 3473.43   44.51 3819.84    45.9
#Mann= 3 , 0 , 0
       0     .12       0 1539.39     .06       0 1569.95     .12       0
#XS Ineff= 2 , 0
       0    1410      40    2280       0      40
Bank Sta=1539.39,1569.95
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,6102    ,344.21,481,356.78
XS GIS Cut Line= 2
     2087323.661        133171.2     2084280.889      131174.381
#Sta/Elev= 30
       0    43.9  174.82   44.08  433.38   38.08  506.28   38.07  542.34   40.08
   557.9   38.41  604.05   37.28 1022.69    35.6 1037.22    33.4 1044.53   35.29
 1190.07   35.87 1194.57   34.71 1208.12   36.04 1334.25   34.81 1339.98    36.2
 1384.87   35.35 1392.67   36.49 2145.73   35.92 2452.39   37.94 2645.39   36.92
  2935.3   40.79 2950.98   39.32 2994.16   39.71 3063.43   42.15 3175.59   42.53
  3201.7   44.46 3222.59   43.32 3472.97   43.31 3514.48   44.97 3639.47   44.09
#Mann= 3 , 0 , 0
       0     .12       0 1022.69     .06       0 1044.53     .12       0
#XS Ineff= 2 , 0
       0     980      40    1930       0      40
Bank Sta=1022.69,1044.53
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,5621    ,419.42,490.06,436.61
XS GIS Cut Line= 2
     2087513.834      132901.788     2084375.976      130778.187
#Sta/Elev= 30
       0   41.41  301.98   39.71  483.21   37.01  877.36   35.01  1265.5   35.55
 1274.99   33.48 1288.23   35.93  1398.6   35.02 1430.75   36.14 1604.86   35.23
 2115.87   36.28 2163.19   37.22 2186.37   36.25 2389.52   36.56 2415.13   37.96
 2451.64   37.15 2494.46   38.65  2523.6   37.46 2537.96   38.38 2562.94   36.89
 2669.68   38.32 2868.42   37.99 2921.93   39.15 2959.37   37.71 3277.01   45.12
 3296.41    44.2 3324.62   45.21 3345.85   43.96 3385.35   45.27 3788.91   45.16
#Mann= 3 , 0 , 0
       0     .12       0  1265.5     .06       0 1288.23     .12       0
#XS Ineff= 2 , 0
       0    1150      40    1920       0      40
Bank Sta=1265.5,1288.23
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,5131    ,403.43,402.25,391.74
XS GIS Cut Line= 2
     2087783.486      132608.217     2084756.445      130466.747
#Sta/Elev= 30
       0   40.88 1148.46   34.72 1409.02   34.97 1420.78   32.98 1427.56   34.82
 1741.31    34.8 1850.34   36.48 1990.87   35.22 2094.82   36.95  2122.5    35.4
 2136.94      37  2228.5   35.75 2268.13   38.59 2276.21   37.14 2505.81   37.49
 2552.43   41.43 2602.86   37.36 2629.48   39.26 2652.17   37.62 2739.77   37.12
 2819.98   38.61  2834.7   40.39 2914.72   38.71 3349.49   43.69 3526.46   44.72
 3576.23   43.45 3617.89   45.18 3632.74   43.59 3646.69   45.24 3707.95   45.49
#Mann= 3 , 0 , 0
       0     .12       0 1409.02     .06       0 1427.56     .12       0
#XS Ineff= 2 , 0
       0    1220      40    1960       0      40
Bank Sta=1409.02,1427.56
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,4728    ,335.31,351.1,328.86
XS GIS Cut Line= 2
     2087941.724      132220.334       2084914.8      130128.428
#Sta/Elev= 30
       0   39.69  170.79   39.51  185.41   40.52  303.45   39.45  394.63   40.58
   594.1   37.54  745.65   37.56  798.97    35.3  889.09   34.76 1372.44   35.43
 1383.32   33.18 1394.51   35.27  1798.9    35.3 1847.37   36.65 1858.95   35.28
 1886.45   36.32  2027.8   35.15 2113.73   36.63 2162.85   34.98 2372.51   36.46
 2439.71   38.15 2501.06   36.54 2567.99   36.72 2579.48   38.05 2617.92   37.06
 2764.36   40.18 2871.74   39.42 3206.51   43.88 3318.98   43.13 3679.45   44.56
#Mann= 3 , 0 , 0
       0     .12       0 1372.44     .06       0 1394.51     .12       0
#XS Ineff= 2 , 0
       0    1140      40    1820       0      40
Bank Sta=1372.44,1394.51
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,4377    ,293.92,310.05,286.29
XS GIS Cut Line= 2
     2088512.243      132204.486     2084946.495       129763.93
#Sta/Elev= 30
       0   39.89  293.68   38.11  520.74   39.76   584.4   37.69  807.73   38.83
  822.62   41.25   832.7   39.38  889.41   38.63  924.63    41.3  967.15   38.35
 1072.93   40.03 1119.72   38.05 1192.19   40.03 1329.96   37.31 1353.78   39.88
 1380.38   36.42 1444.61   35.06 1927.16   35.31 1938.17   32.94 1948.76   35.05
 2054.96    34.2 2215.54   37.13 2583.82   35.61 2761.65    38.3 2937.53   37.22
 3010.12   39.94 3248.51   37.76 3699.96   45.06 3797.84   43.38 4320.98   45.28
#Mann= 3 , 0 , 0
       0     .12       0 1927.16     .06       0 1948.76     .12       0
#XS Ineff= 2 , 0
       0    1610      42    2260       0      40
Bank Sta=1927.16,1948.76
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,4067    ,287.11,301.69,281.12
XS GIS Cut Line= 2
     2088623.178      131919.226     2084962.343      129446.974
#Sta/Elev= 30
       0   39.98  203.68   38.26  630.57   39.08  659.35   37.88  685.59   39.29
  762.38   37.92  854.16   40.02  957.72   38.37 1018.54   40.39 1479.03   34.34
 1784.65   34.36 1794.84   32.76 1806.73   34.31 2361.62   37.93  2633.4   36.77
 2789.57   38.32 2865.88   37.12 2978.42   39.49 3151.93   38.29 3194.55   38.53
  3219.5   41.33 3240.19   38.52 3264.35   39.63 3381.73   36.49 3392.23   38.07
 3487.65   38.68 3505.63   40.67 3800.33   44.94 4119.93   43.64 4417.44   44.78
#Mann= 3 , 0 , 0
       0     .12       0 1784.65     .06       0 1806.73     .12       0
#XS Ineff= 2 , 0
       0    1560      40    2180       0      40
Bank Sta=1784.65,1806.73
Exp/Cntr=.3,.1
