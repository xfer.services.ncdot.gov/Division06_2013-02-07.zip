HEC-RAS study SF230075BigBranch.prj: SF230075 Big Branch SR 1006

--- SF230075BigBranch.g01 (geometry) --- (continued)

Type RM Length L Ch R = 1 ,3766    ,342.57,348.16,351.15
XS GIS Cut Line= 2
     2088623.178      131570.575     2085041.582      129177.562
#Sta/Elev= 30
       0   40.04 1049.94   37.74 1078.86   38.55 1160.06   35.92  1242.5   36.82
 1357.58   35.63 1368.13   34.51 1533.46   34.28 1545.89   32.39 1553.79    34.4
 1731.06   34.34 1884.65   37.78 1917.32   36.69 2293.91   38.01 2303.29   36.26
 2308.09   37.96 2379.22   38.22 2394.34   37.13  2448.7   38.26  2740.5   35.74
 2982.88   36.92 3208.53   36.09 3565.44   38.88 3602.72   38.11 3613.26   39.91
 3655.97   42.01 3724.76   41.22 3732.78   42.09  3776.5   40.74 4307.48   45.06
#Mann= 3 , 0 , 0
       0     .12       0 1533.46     .06       0 1553.79     .12       0
#XS Ineff= 2 , 0
       0    1380      40    1950       0      40
Bank Sta=1533.46,1553.79
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,3417    ,400.74,526.4,687.35
XS GIS Cut Line= 3
     2087973.419      131095.142     2087830.789      130635.557
     2085184.212      128797.216
#Sta/Elev= 30
       0   39.32  534.39   39.17     664   37.95  734.11   34.34  870.35   34.72
  877.29   32.77  888.87   34.67 1063.97   34.82 1149.31   37.56  1301.2   36.98
 1447.81   37.97  2039.9   36.03 2852.46   36.56 2862.41   38.17 2933.21   38.11
 2936.31   39.05 3004.97   37.94 3023.58   39.19  3026.8   38.23 3040.41   38.23
 3149.19   39.77 3231.08   39.58 3261.49    41.1 3270.65   39.91 3310.83   39.81
 3335.34   41.07 3394.77   40.33 3442.92   43.37 3482.33   42.29 3703.61   43.78
#Mann= 3 , 0 , 0
       0     .12       0  870.35     .06       0  888.87     .12       0
#XS Ineff= 2 , 0
       0                    1200       0      40
Bank Sta=870.35,888.87
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,2891    ,367.94,337.3,292.03
XS GIS Cut Line= 3
     2088020.963       130968.36      2087894.18       129763.93
     2085596.254      128305.935
#Sta/Elev= 30
       0   38.91  391.81   37.82  401.75   36.54  534.92   37.99  591.39   36.89
  626.56   34.28  814.03   34.69   829.7   32.92   833.7   34.98  908.63    34.8
  926.35   36.63  990.58   34.32  1007.4   36.57 1161.38   39.12 1356.42   37.15
 1500.41   38.95 1614.56   36.51 1793.19   38.69 2133.98   36.01 2150.98   38.64
 2475.67   37.53  2726.8      39 2960.36   36.27 3094.24   36.92 3150.73   40.35
 3218.15   41.47  3252.2    39.2 3358.87   40.63 3482.24   37.76 3932.52   41.01
#Mann= 3 , 0 , 0
       0     .12       0  814.03     .06       0   833.7     .12       0
#XS Ineff= 2 , 0
       0     550      40    1160       0      40
Bank Sta=814.03,833.7
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,2554    ,705.08,616.29,557.87
XS GIS Cut Line= 3
     2088670.721      131031.751     2088068.506        129621.3
     2085675.493      128115.762
#Sta/Elev= 30
       0   39.71  101.63    39.7  144.42   36.71  216.19   36.89  260.58   39.16
  463.35   36.62  709.28   37.11  795.96   34.15 1068.41   35.08 1078.87      33
 1085.85   34.74 1134.14   35.03 1168.15   37.59 1255.37   36.12 1374.98   39.63
 1858.86   39.55 2035.67   36.65 2182.59   39.62 2377.32   39.62 2525.59   37.13
 2573.46   39.43  2579.6   38.04 2839.99   37.72 3157.15    39.6 3444.86   36.21
 3591.58   37.67 3644.85   40.25 3687.09    37.2 3860.96   37.26 4360.85   41.83
#Mann= 3 , 0 , 0
       0     .12       0 1068.41     .06       0 1085.85     .12       0
#XS Ineff= 2 , 0
       0     660      40    1400       0      40
Bank Sta=1068.41,1085.85
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,1937    ,354.14,474.3,402.91
XS GIS Cut Line= 4
     2089221.329       131320.74     2089139.449      130018.848
     2088001.317      129101.792     2085700.489      128012.788
#Sta/Elev= 30
       0   34.79   705.7   34.24  714.17   36.14  893.48   36.37   930.5    34.7
  957.94   36.83 1007.01   34.68 1833.09   35.72 1977.19   33.38 1992.55   31.66
 1997.17   33.37 2245.68   32.83 2263.18   35.13 2359.42   33.19 2491.48   36.75
 2585.36   34.25 2884.07    33.5 3315.87   38.78  3429.5   38.09 3451.69   35.08
 3599.14   40.58  4279.5   36.53  4310.5   38.49  4548.3   36.58 4571.34   39.02
 4631.94   36.66 4872.86   37.22 5076.01   39.33 5107.97   41.89 5311.62   42.49
#Mann= 3 , 0 , 0
       0     .12       0 1977.19     .06       0 1997.17     .12       0
#XS Ineff= 2 , 0
       0    1350      49    2410       0      49
Bank Sta=1977.19,1997.17
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,1463    ,489.6,488,431.31
XS GIS Cut Line= 4
     2089352.337      131451.748     2089401.465      129838.712
     2088312.461      128831.588     2085725.053      127816.276
#Sta/Elev= 30
       0   35.33  597.17   34.48  673.29   36.52  718.78   34.56   874.2   34.06
  901.03    35.7 1119.97   34.75 1157.52    36.6 1223.97   34.52  1483.4   35.73
 1730.14   33.64 2133.95   34.52 2638.59   33.11 2644.01   31.13 2655.25    33.1
  2940.5   34.73 2949.19   33.12 3091.49   34.46  3276.4   33.26 3302.67   34.59
 3465.47   33.18 3891.77    37.4 4301.88   36.76 4342.08   38.84 5260.89   36.29
 5505.63   39.53 5610.96   38.68 5730.82   41.23 5761.88    43.5 5876.59   42.38
#Mann= 3 , 0 , 0
       0     .12       0 2638.59     .06       0 2655.25     .12       0
#XS Ineff= 2 , 0
       0    1640      49    3110       0      49
Bank Sta=2638.59,2655.25
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,975     ,481.59,499.64,473.2
XS GIS Cut Line= 4
     2089794.489      131558.192     2089892.745      129503.004
     2088402.529      128422.188     2085725.053      127693.456
#Sta/Elev= 30
       0   37.27   28.68   38.33   56.41   35.41  183.53   34.14 1225.05   35.34
 1241.97   33.85 1777.99   33.82 1861.15   35.31 2344.05   32.97  2477.1   33.33
 2508.06   35.12 2573.14   33.37 3216.53   32.89  3229.9   30.97 3236.55   33.19
 3728.61   33.88 3758.25   35.54 3846.23   33.39 4029.19   33.19 4302.45   33.46
 4373.63   35.44 4591.15    33.5  4652.5   35.07 5249.07   33.99 5476.51   37.87
  5727.1   38.48 5910.96    35.6 6357.37   37.97 6473.36   41.26 6673.31   42.76
#Mann= 3 , 0 , 0
       0     .12       0 3216.53     .06       0 3236.55     .12       0
#XS Ineff= 2 , 0
       0    2070      49    3980       0      49
Bank Sta=3216.53,3236.55
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,475     ,381.2,435.06,451.38
XS GIS Cut Line= 4
     2090023.753       131566.38     2090293.957       129191.86
     2088508.973       127922.72     2085667.737      127447.816
#Sta/Elev= 30
       0   34.91   395.5   35.77  671.94   33.76  823.39   35.78  976.91   33.66
 1689.98   35.25  1844.2   33.55 1927.29   35.12 2095.05   33.22 2909.19   33.02
 3685.57   34.28 3695.53   31.87 3707.95   33.84 4534.85   35.54 4595.97   33.77
  4908.6   33.96 5172.96   35.87 5208.54   33.49 5813.56   35.19 5861.87   33.45
 5918.38    35.1 6295.98   33.97 6355.09   34.75 6367.06   36.98 6550.24   34.43
 6701.39   37.78 6771.73   36.65 7021.84   38.51 7058.43   40.62 7460.67   42.51
#Mann= 3 , 0 , 0
       0     .12       0 3685.57     .06       0 3707.95     .12       0
#XS Ineff= 2 , 0
       0    2620      49    4730       0      49
Bank Sta=3685.57,3707.95
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,40      ,40.35,40.35,40.35
XS GIS Cut Line= 4
     2090253.017      131550.004     2090465.905      129159.108
     2088721.861      127316.808     2085602.233      127161.236
#Sta/Elev= 30
       0   34.51   497.6   33.94  542.48    36.4  682.16   33.66 1029.94   36.22
 1076.82   33.75 1093.95   35.23  1504.7   33.63    1673   35.25 1764.71   33.29
 2035.69   35.14 2477.55    33.1  3901.4   34.53 3907.31   31.89 3925.58   33.74
 4262.81   33.46  4350.9   36.79 4404.91   34.06 4508.76   33.57 4606.49   35.48
 4936.53   33.51 5649.01   33.51 5663.69   35.21 5783.07   33.28 6885.62   33.43
 7181.04   38.73 7374.07   37.46 7450.48   40.18 7711.51   39.25 8060.74   41.79
#Mann= 3 , 0 , 0
       0     .12       0  3901.4     .06       0 3925.58     .12       0
#XS Ineff= 2 , 0
       0    2800      49    4950       0      49
Bank Sta=3901.4,3925.58
Exp/Cntr=.3,.1

Chan Stop Cuts=-1

--- SF230075BigBranch.g02 (geometry) ---

Geom Title=Corrected Effective
Program Version=4.10

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
River Reach=Big Branch      ,Big Branch

Type RM Length L Ch R = 1 ,7933    ,104.18,106.99,105.91
BEGIN DESCRIPTION:
Section 7933 Channel Geometry revised
END DESCRIPTION:
XS GIS Cut Line= 6
        2086000.         134114.     2084843.082      133585.337
     2084767.452      133522.311     2084683.417      133389.957
     2084628.795      133259.704     2084601.484      133030.711
#Sta/Elev= 30
       0   46.13   53.38   45.62   77.43   46.72  170.79   46.09  260.36   44.55
  385.33    40.2  472.52   39.94  497.48   38.18  531.05   39.22   553.3   38.28
  573.16   39.17  651.33   36.99     766      37     780    34.3     783    36.5
     796      34     820      37   878.6   36.38  937.31   39.03  966.45   38.45
 1170.91   40.26 1376.11   40.82  1468.5      40 1488.11   38.83 1662.44   40.04
 1824.14   38.49 1840.46   38.84 1846.78   39.92 1855.03   39.38  1899.1   40.51
#Mann= 3 , 0 , 0
       0     .12       0     766     .06       0     820     .12       0
#XS Ineff= 2 , 0
       0     734    40.1     835       0      40
Permanent Ineff=
       F       F
Bank Sta=766,820
XS Rating Curve= 0 ,0
Exp/Cntr=0.5,0.3

Type RM Length L Ch R = 3 ,7890    ,,,
BEGIN DESCRIPTION:
SR 1006 -- Columbus County Bridge #75
END DESCRIPTION:
Bridge Culvert--1,0,-1,-1, 0
Deck Dist Width WeirC Skew NumUp NumDn MinLoCord MaxHiCord MaxSubmerge Is_Ogee
36,26,2.6,0, 52, 52, , , 0.95, 0, 0,0,,
       0    3.32    34.4   41.46   48.03    55.1   63.51   82.87   89.07   98.83
  101.47  109.48  121.76  156.83  164.04  176.57  183.83  195.45  199.94     220
     433     597     779     779   780.5   813.5     815     815     868    1064
    1240 1280.25 1296.03 1324.15 1383.71  1410.7 1439.73 1554.62  1567.7 1584.36
 1624.13 1637.47 1681.46 1705.62 1711.22 1723.42 1724.18  1729.4 1735.44  1741.7
 1754.39 2051.62
    45.8   45.72    45.5   45.42    45.4   45.28   45.33   45.17   45.17   45.04
   44.97   44.89    44.8   44.42   44.32   44.24   44.16   44.13   44.02    44.4
      41    40.9    40.1    42.4    42.4    42.4    42.4    40.1    40.1      40
    40.1   40.19   40.38   40.44   40.63   40.63   40.67    40.8    40.8   40.82
   40.86   40.86    40.8   40.76   40.72   40.66    40.6   40.49   40.46   40.39
   40.33   39.85
                                    38.4    38.4
       0    3.32    34.4   41.46   48.03    55.1   63.51   82.87   89.07   98.83
  101.47  109.48  121.76  156.83  164.04  176.57  183.83  195.45  199.94     220
     433     597     779     779   780.5   813.5     815     815     868    1064
    1240 1280.25 1296.03 1324.15 1383.71  1410.7 1439.73 1554.62  1567.7 1584.36
 1624.13 1637.47 1681.46 1705.62 1711.22 1723.42 1724.18  1729.4 1735.44  1741.7
 1754.39 2051.62
    45.8   45.72    45.5   45.42    45.4   45.28   45.33   45.17   45.17   45.04
   44.97   44.89    44.8   44.42   44.32   44.24   44.16   44.13   44.02    44.4
      41    40.9    40.1    42.4    42.4    42.4    42.4    40.1    40.1      40
    40.1   40.19   40.38   40.44   40.63   40.63   40.67    40.8    40.8   40.82
   40.86   40.86    40.8   40.76   40.72   40.66    40.6   40.49   40.46   40.39
   40.33   39.85
                                    38.4    38.4
Pier Skew, UpSta & Num, DnSta & Num=  ,797, 2 ,797, 2 , 0 , 0 , 0 ,,
       2       2
      25      39
       2       2
      25      39
Abutment Skew #Up #Dn= , 3 , 3
   780.5   782.5   782.5
    38.4    38.4      20
   780.5   782.5   782.5
    38.4    38.4      20
Abutment Skew #Up #Dn= , 3 , 3
   811.5   811.5   813.5
      20    38.4    38.4
   811.5   811.5   813.5
      20    38.4    38.4
BR Coef=-1 , 1 , 0 ,, 0 ,,,0.8,0,1.2,0,
WSPro=,,,, 1 ,,,, 0 ,,,, 0 ,,,,-1 ,-1 ,-1 , 0 , 0 , 0 , 0 , 0
BR U #Sta/Elev= 232
       0   46.13    3.85   46.04   25.79   45.86   32.04   45.77   38.87   45.73
   44.92   45.75   47.36   45.69   53.38   45.62   63.03   45.86   64.12   45.95
   66.15   46.41   71.28   46.66   77.43   46.72   84.61   46.54   91.46   46.45
  110.71    46.4  122.31   46.18  132.39   46.18   137.9    46.2  147.43   46.13
  170.79   46.09  179.18   45.94  182.45   45.78  190.44   45.54  218.13    45.1
  226.14   45.04  230.62   44.92  237.28   44.83  243.32   44.82  260.36   44.55
  260.97   44.49  270.33   44.18  274.06   44.09  278.75   43.86  288.86   43.44
   306.4   42.91     325   42.16  330.75   42.05  333.76    41.8  346.74   41.33
  355.85   41.15   357.9   41.01   370.9   40.79  377.29   40.61  379.61   40.51
  383.28   40.29  385.33    40.2  394.76   40.07  397.82      40  409.42   39.84
  416.23   39.83  418.43   39.92  420.52    39.8  427.03   40.54  436.33   40.02
  438.36   39.71  445.16   39.88  459.26   39.71  464.87   39.85  472.52   39.94
  495.76   38.29  497.48   38.18  508.46   38.14  515.99   38.44  520.52   38.95
   526.6   39.13  531.05   39.22  533.52   39.17   553.3   38.28  568.88   39.06
  573.16   39.17  577.37   39.08  582.52   38.84  595.45   38.33  609.03   38.38
  618.09   38.32  621.29   38.02  629.97   37.56  631.36   37.64  639.39   37.53
  651.33   36.99  654.44   37.07  669.58   37.02  672.24   37.31  673.11   37.37
  673.31   37.45  681.39   37.49  683.71   37.36  694.72   37.17  706.99   37.13
  715.17   37.23   722.1   37.38  726.13   37.21   733.2   37.08  752.23   36.73
  758.35   36.69  764.62   36.92  767.47   37.05     778    36.7   780.5    35.2
     785    33.4     790    32.9     797    32.5     804      33     809    34.2
   813.5    35.2   820.3   36.98  825.37   36.62  829.63   36.69  836.86   36.71
  842.46   36.86  846.15   36.76  851.73   36.53   861.7   36.81  866.42   36.42
  867.52   36.34   878.6   36.38   888.9   36.68  902.52   37.25   917.4   37.98
  923.84   38.67  934.43   38.97  937.31   39.03  953.59   38.73  966.45   38.45
  971.31   38.56  980.44   38.57  989.99   38.67  995.13   38.81 1002.38   38.85
 1010.47    39.2 1024.43   39.43 1030.44   39.39 1039.58   39.33 1049.36   39.42
 1060.19   39.58 1071.06   39.56 1072.66   39.62 1078.85   39.78 1085.08   39.85
 1088.07   39.92 1115.83   40.04 1140.05   39.96 1143.47   40.08 1160.93   40.16
 1163.77   40.22 1170.91   40.26 1183.45   40.11 1194.54   40.17 1197.99   40.26
 1217.89   40.35 1227.71   39.93 1233.94    39.9 1249.62   40.08 1251.25   40.14
 1265.53   40.25 1271.04   40.23 1276.58   40.24 1285.26   40.06 1295.73   40.07
  1302.4   40.16 1310.68   40.19 1323.66   40.46 1339.18    40.6 1355.28   40.69
 1363.02   40.71 1370.47   40.82 1376.11   40.82 1380.18   40.75 1386.82   40.72
 1389.72   40.64 1402.46   40.23 1406.27   40.04 1431.37   40.17 1432.02   40.02
 1432.47   39.95 1434.63   40.04  1441.2   39.71 1446.98   39.97 1448.31   40.09
 1457.66   40.07 1462.77   40.09  1468.5      40 1480.21    39.4 1482.62   39.33
 1488.11   38.83  1490.3   38.99 1495.11   39.21 1499.92   39.27 1507.46   39.21
 1512.89   39.23 1527.25   39.33 1532.73   39.37 1544.59   39.51 1550.36   39.61
 1562.88    39.7 1566.28   39.76  1579.3   39.74 1601.53   39.82 1607.84   40.02
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BR U #Mann= 3
       0     .12     778     .05   820.3     .12
BR U Banks=778,820.3
BR D #Sta/Elev= 244
       0   45.53    6.43   45.54   15.65   45.66   42.18   45.67   51.44    45.6
   54.84   45.65   67.21   45.68   76.05   45.64  107.99   45.63  121.15   45.57
  127.41   45.75  128.71   45.82  136.27   45.97  143.47   45.79  148.47   45.56
  150.66   45.49  158.59   45.47  165.74   45.54  183.65   45.46  205.16   45.27
  209.18   45.17  225.23   44.69  226.48   44.63  232.76   44.27   235.3   44.17
  244.86   43.88  257.51   43.62  265.85   43.52  271.58   43.38  294.69   42.91
  309.91   42.42  311.29   42.32  326.97   41.91  332.75   41.85  336.61   41.71
  350.63   41.55  354.11   41.45  355.77   41.37  364.18   41.14  367.26   41.04
  373.32   40.92  385.56   40.81  389.69   40.73  402.12   40.47  421.57   40.26
  439.73   40.48  443.53   40.54  449.15    40.5  454.41   40.52  478.08   39.98
  479.93   39.71  491.96   39.74  502.43   38.99  510.94   38.12     522   38.53
  530.38   38.47  543.16   37.93  547.61   37.68  549.72   37.94  559.51    36.9
  565.15   37.09  568.44   37.25  581.65   36.83  588.59   37.67   592.8   37.74
  599.86   37.59  601.94   37.41  609.09   36.89  620.85   36.95  631.05    36.7
  644.42   36.64  661.72   36.79  672.58   36.85  675.01   36.76   678.5   36.52
  681.26   36.45  689.22   36.57  698.03   36.59  701.65   36.72  708.14   36.95
     728   37.11   734.2   37.29  742.46   37.47  749.53   37.53  757.11   37.42
  765.96   37.13  779.25    37.1   780.5    36.3     785    34.8     790    34.2
     797    32.5     804    31.6     808    32.6   813.5      34   821.3   36.92
  825.65   36.81  833.98   36.62  839.92    36.6  852.52   36.74  862.96   36.71
  873.27   36.72  881.71   37.03  883.19   37.13  884.88    37.2  896.68   37.16
  901.23   37.25  908.19   37.27  917.24   37.78  918.91   37.84  923.98   37.95
     935   38.03  940.24   37.98  952.49   37.99  967.02    38.2  983.02   38.73
 1019.52   38.56  1041.4   38.33 1044.15   38.27 1055.25   38.17 1062.83   38.16
 1065.06   38.22 1071.81   38.29 1076.08    38.6 1084.42   38.58 1089.43   38.28
 1094.46   38.37 1100.87   38.38 1101.53   38.19 1104.94   38.32 1110.33   38.42
 1116.73   38.66 1119.05   38.72 1122.77   38.63 1135.06    38.1 1139.02   38.28
 1140.07   38.16 1148.32   38.06 1150.15   38.14  1160.8   38.71 1162.49   38.78
 1164.36   38.67  1168.2   38.58 1173.97   38.56 1177.39   38.47  1179.6   38.53
 1185.97   38.42 1189.35   38.26 1190.24   38.15 1194.57   38.23 1196.74   38.48
 1199.62   38.57 1210.45   38.65 1214.17    38.6 1224.86   38.48 1243.74   38.76
 1255.95   38.65 1265.17   38.42 1272.42    38.4 1278.06   38.59 1291.65   38.56
  1297.6   38.43 1309.85    38.6 1318.07   38.48  1346.8   39.04 1360.07   39.27
 1380.71    39.3  1381.5   39.37 1390.39   39.33 1401.87   39.07  1409.4      39
 1414.58   39.02 1420.09   39.11 1425.67   39.15 1434.19   39.34  1442.5   39.46
 1452.68   39.39  1456.5   39.31 1462.35   39.27 1467.46   38.85 1476.47   38.75
 1481.36   38.65 1487.64   38.62 1501.14   38.42 1508.04   38.67 1526.01   38.68
 1530.63   38.61 1539.65   38.67  1544.9   38.68 1548.89    38.8 1565.24      39
 1571.63   38.96 1578.07   39.09 1582.29   39.27 1595.92   39.79 1598.04   39.91
    1610   39.59 1612.61   39.43 1618.28   39.03 1626.46   39.06 1632.72   39.18
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BR D #Mann= 3
       0     .12  779.25     .05   821.3     .12
BR D Banks=779.25,821.3
BC Design=,, 0 ,, 0 ,,,,,,
BC HTab HWMax=46.72
BC Use User HTab Curves=0
BC User HTab FreeFlow(D)= 0

Type RM Length L Ch R = 1 ,7826    ,367.06,401.59,406.65
BEGIN DESCRIPTION:
7826 Channel Geometry Revised
END DESCRIPTION:
XS GIS Cut Line= 6
     2086045.436      134023.284     2084788.426       133431.48
     2084740.256       133353.49     2084698.967      133218.155
        2084690.         132995.        2084590.         132932.
#Sta/Elev= 30
       0   45.53  205.16   45.27  373.32   40.92  491.96   39.74  510.94   38.12
  530.38   38.47  559.51    36.9   592.8   37.74  681.26   36.45     787    37.2
     794    33.4     801    33.1     803    35.5     806    36.9  873.27   36.72
  983.02   38.73 1148.32   38.06 1162.49   38.78 1190.24   38.15  1442.5   39.46
 1501.14   38.42 1598.04   39.91 1721.72   38.16 1774.58   38.46 1824.39   36.89
  1841.4   38.78 1867.97   39.39 1926.05   38.68  1936.8   40.07 1964.66   40.47
#Mann= 3 , 0 , 0
       0     .12       0     787     .06       0     806     .12       0
#XS Ineff= 2 , 0
       0     770      39     870       0      39
Permanent Ineff=
       F       F
Bank Sta=787,806
XS Rating Curve= 0 ,0
Exp/Cntr=0.5,0.3
